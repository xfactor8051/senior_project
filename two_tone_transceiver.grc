options:
  parameters:
    author: esteban
    generate_options: qt_gui
    id: two_tone_recieve
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tone
  id: variable
  parameters:
    value: '0'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.05e6
    low_cutoff_freq: .95e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2.05e6
    low_cutoff_freq: 1.95e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class blk(gr.sync_block):  
          """Embedded Python Block for detecting two specific tones"""

          def __init__(self, threshold=0.1, flag_file="/tmp/tone_detected.flag"):  
              gr.sync_block.__init__(
                  self,
                  name='detect_two_tone',  
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]  
              )
              self.threshold = threshold
              self.flag_file = flag_file
              self.message_port_register_out(pmt.intern("out"))  # Register the output message port

          def work(self, input_items, output_items):
              """Check if both tones are present"""
              rms_431 = input_items[0]
              rms_432 = input_items[1]
              out = output_items[0]

              # Check if the RMS values exceed the threshold
              if np.mean(rms_431) > self.threshold and np.mean(rms_432) > self.threshold:
                  tone_value = 1  # Detected the correct combination
              else:
                  tone_value = 0  # Did not detect the correct combination

              # Send a PMT message to update the flag
              self.message_port_pub(pmt.intern("out"), pmt.from_long(tone_value))

              # Pass the value to the output for other blocks
              out[:] = float(tone_value)

              # Write the tone_value to a file for higher-level Python code to read
              with open(self.flag_file, 'w') as f:
                  f.write(str(tone_value))

              return len(output_items[0])
    flag_file: '"/tmp/tone_detected.flag"'
    threshold: '.01'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  
          """Custom Block to multiply complex signal source by a message-controlled value"""

          def __init__(self, default_value=1.0):  
              gr.sync_block.__init__(
                  self,
                  name='amplitude_control_complex',  
                  in_sig=[np.complex64],  # Complex input
                  out_sig=[np.complex64]  # Complex output
              )
              self.amplitude = default_value  # Default amplitude value
              self.message_port_register_in(pmt.intern("in"))  # Register message input
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)  # Set handler for incoming messages

          def handle_msg(self, msg):
              """Handle incoming messages to update amplitude"""
              # Parse the incoming PMT long integer message
              msg_value = pmt.to_long(msg)

              # Invert the amplitude based on message value: amplitude is 1.0 when message is 0, and 0.0 when message is 1
              if msg_value == 1:
                  self.amplitude = 0.0  # Inverted logic: message 1 means amplitude 0
              elif msg_value == 0:
                  self.amplitude = 1.0  # Inverted logic: message 0 means amplitude 1

          def work(self, input_items, output_items):
              """Multiply the complex input signal by the amplitude"""
              signal = input_items[0]
              output_items[0][:] = self.amplitude * signal  # Apply amplitude to the complex signal

              return len(output_items[0])
    default_value: '1'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  
          """Custom Block to multiply complex signal source by a message-controlled value"""

          def __init__(self, default_value=1.0):  
              gr.sync_block.__init__(
                  self,
                  name='amplitude_control_complex',  
                  in_sig=[np.complex64],  # Complex input
                  out_sig=[np.complex64]  # Complex output
              )
              self.amplitude = default_value  # Default amplitude value
              self.message_port_register_in(pmt.intern("in"))  # Register message input
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)  # Set handler for incoming messages

          def handle_msg(self, msg):
              """Handle incoming messages to update amplitude"""
              # Parse the incoming PMT long integer message
              msg_value = pmt.to_long(msg)

              # Invert the amplitude based on message value: amplitude is 1.0 when message is 0, and 0.0 when message is 1
              if msg_value == 1:
                  self.amplitude = 0.0  # Inverted logic: message 1 means amplitude 0
              elif msg_value == 0:
                  self.amplitude = 1.0  # Inverted logic: message 0 means amplitude 1

          def work(self, input_items, output_items):
              """Multiply the complex input signal by the amplitude"""
              signal = input_items[0]
              output_items[0][:] = self.amplitude * signal  # Apply amplitude to the complex signal

              return len(output_items[0])
    default_value: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-430e6'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 2.1e6, 1e3 )
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_5
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: 435e6
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: '0'
    center_freq: 420e6
    gain: '40.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_1, '0']
- [analog_sig_source_x_1, '0', epy_block_2, '0']
- [band_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_1, '0', blocks_rms_xx_1, '0']
- [band_pass_filter_1, '0', qtgui_freq_sink_x_2, '0']
- [blocks_add_xx_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_rms_xx_0, '0', epy_block_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_1, '0', epy_block_0, '1']
- [blocks_rms_xx_1, '0', qtgui_number_sink_1, '0']
- [epy_block_0, '0', qtgui_number_sink_2, '0']
- [epy_block_0, out, blocks_message_debug_0, log]
- [epy_block_0, out, epy_block_1, in]
- [epy_block_0, out, epy_block_2, in]
- [epy_block_1, '0', blocks_add_xx_0, '0']
- [epy_block_1, '0', qtgui_freq_sink_x_4, '0']
- [epy_block_2, '0', blocks_add_xx_0, '1']
- [epy_block_2, '0', qtgui_freq_sink_x_5, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
