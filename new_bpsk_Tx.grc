options:
  parameters:
    author: esteban
    generate_options: qt_gui
    id: new_bpsk_Tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '''10100001110001001111001011100111'''
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_code, threshold)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 256e3
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/sf_sharedfolder_VM/test.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '60'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class preamble_inserter(gr.sync_block):
          def __init__(self, preamble=0xAAAAAAAAAAAAAAAA, pkt_len=64):
              gr.sync_block.__init__(
                  self,
                  name='64-bit Preamble Inserter',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.preamble = preamble.to_bytes(8, byteorder='big')
              self.pkt_len = pkt_len
              self.preamble_sent = False
              self.tag_position = 0

          def work(self, input_items, output_items):
              if not self.preamble_sent:
                  # Insert the preamble
                  output_items[0][:8] = np.frombuffer(self.preamble, dtype=np.uint8)
                  self.preamble_sent = True
                  self.tag_position += 8
                  return 8
              
              # Pass the input items after sending the preamble
              output_len = len(input_items[0])
              output_items[0][:output_len] = input_items[0]
              
              # Attach a packet length tag
              tag_key = pmt.intern("packet_len")
              tag_value = pmt.from_long(self.pkt_len)
              self.add_item_tag(0, self.tag_position, tag_key, tag_value)
              self.tag_position += output_len
              
              return output_len
    pkt_len: '64'
    preamble: '0xAAAAAAAAAAAAAAAA'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: 5e6
    center_freq: 433e6
    gain: '30.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', epy_block_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', blocks_tagged_stream_mux_0, '1']
- [epy_block_0, '0', digital_protocol_formatter_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
