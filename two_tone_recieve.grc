options:
  parameters:
    author: esteban
    generate_options: qt_gui
    id: two_tone_recieve
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 6e3
    low_cutoff_freq: 4e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 16e3
    low_cutoff_freq: 14e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
          """Embedded Python Block for detecting two specific tones"""

          def __init__(self, threshold=0.1):  
              gr.sync_block.__init__(
                  self,
                  name='detect_two_tone',  
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]  
              )
              self.threshold = threshold
              self.flag_file = "/tmp/tone_detected.flag"  # Path to the flag file

          def work(self, input_items, output_items):
              """Check if both tones are present"""
              rms_430 = input_items[0]
              rms_435 = input_items[1]
              out = output_items[0]

              # Check if the RMS values exceed the threshold
              if np.mean(rms_430) > self.threshold and np.mean(rms_435) > self.threshold:
                  out[:] = 1.0  # Detected the correct combination
                  # Set the flag by writing to the file
                  with open(self.flag_file, 'w') as f:
                      f.write("1")
              else:
                  out[:] = 0.0  # Did not detect the correct combination
                  # Clear the flag by removing the file
                  with open(self.flag_file, 'w') as f:
                      f.write("0")

              return len(output_items[0])
    threshold: '.001'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-433e6'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 30e3, 1e3)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: 5e6
    center_freq: 433e6
    gain: '40.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_1, '0', blocks_rms_xx_1, '0']
- [band_pass_filter_1, '0', qtgui_freq_sink_x_2, '0']
- [blocks_rms_xx_0, '0', epy_block_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_1, '0', epy_block_0, '1']
- [blocks_rms_xx_1, '0', qtgui_number_sink_1, '0']
- [epy_block_0, '0', qtgui_number_sink_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
